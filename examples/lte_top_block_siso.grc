options:
  parameters:
    author: Johannes Demel
    category: Custom
    generate_options: qt_gui
    id: lte_top_block_siso
    output_language: python
    title: LTE top level flowgraph SISO
  states: {}

blocks:
- name: N_rb_dl
  id: variable
  parameters:
    value: '6'
  states: {}
- name: fftlen
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: frame_key
  id: variable
  parameters:
    value: '"slot"'
  states: {}
- name: interp_val
  id: variable
  parameters:
    value: int(samp_rate/1e4)
  states: {state: disabled}
- name: pbch_descr_key
  id: variable
  parameters:
    value: '"descr_part"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (7*fftlen + 160* fftlen/2048 + 6 * (144 * fftlen/2048)) / 0.0005
  states: {}
- name: MIB
  id: lte_mib_unpack_vbm
  parameters: {}
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate * 2)
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: '1815000000'
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '30720000'
  states: {}
- name: lte_bch_decoder_0
  id: lte_bch_decoder
  parameters: {}
  states: {}
- name: lte_channel_estimator_0
  id: lte_channel_estimator
  parameters:
    N_rb_dl: N_rb_dl
    estimator_key: '"slot"'
    initial_id: '124'
  states: {}
- name: lte_cp_ffo_sync_0
  id: lte_cp_ffo_sync
  parameters:
    fftlen: fftlen
  states: {}
- name: lte_ofdm_demodulator_0
  id: lte_ofdm_demodulator
  parameters:
    N_rb_dl: N_rb_dl
    fftlen: fftlen
    ofdm_key: '"slot"'
  states: {}
- name: lte_pbch_decoder_0
  id: lte_pbch_decoder
  parameters:
    N_rb_dl: '50'
  states: {}
- name: lte_pcfich_decoder_0
  id: lte_pcfich_decoder
  parameters:
    N_rb_dl: N_rb_dl
    key: '"slot"'
  states: {}
- name: lte_pss_sync_0
  id: lte_pss_sync
  parameters:
    fftlen: fftlen
  states: {}
- name: lte_sss_sync_0
  id: lte_sss_sync
  parameters:
    N_rb_dl: N_rb_dl
    fftlen: fftlen
    group_key: '"N_id_2"'
    offset_key: '"offset_marker"'
  states: {}
- name: pre_blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/nimra/storage/lte_sim.dat
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: pre_rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1000'
    interp: interp_val
    taps: ''
    type: ccc
  states: {state: disabled}
- name: sync_lte_rough_symbol_sync_cc_0
  id: lte_rough_symbol_sync_cc
  parameters:
    fftl: fftlen
    vlen: '1'
  states: {}

connections:
- [MIB, N_ant, lte_pcfich_decoder_0, N_ant]
- [blocks_add_xx_0, '0', blocks_head_0_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_deinterleave_0, '0', blocks_add_xx_0, '1']
- [blocks_deinterleave_0, '1', blocks_add_xx_0, '0']
- [blocks_head_0_0, '0', blocks_throttle_0, '0']
- [blocks_head_0_0, '0', sync_lte_rough_symbol_sync_cc_0, '0']
- [blocks_throttle_0, '0', pre_rational_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', sync_lte_rough_symbol_sync_cc_0, '0']
- [iio_pluto_source_0, '0', sync_lte_rough_symbol_sync_cc_0, '0']
- [lte_bch_decoder_0, '0', MIB, '0']
- [lte_bch_decoder_0, '1', MIB, '1']
- [lte_channel_estimator_0, '0', lte_pbch_decoder_0, '1']
- [lte_channel_estimator_0, '0', lte_pcfich_decoder_0, '1']
- [lte_channel_estimator_0, '1', lte_pbch_decoder_0, '2']
- [lte_channel_estimator_0, '1', lte_pcfich_decoder_0, '2']
- [lte_cp_ffo_sync_0, '0', lte_sss_sync_0, '0']
- [lte_ofdm_demodulator_0, '0', lte_channel_estimator_0, '0']
- [lte_ofdm_demodulator_0, '0', lte_pbch_decoder_0, '0']
- [lte_ofdm_demodulator_0, '0', lte_pcfich_decoder_0, '0']
- [lte_pbch_decoder_0, '0', lte_bch_decoder_0, '0']
- [lte_pss_sync_0, '0', lte_cp_ffo_sync_0, '0']
- [lte_sss_sync_0, '0', lte_ofdm_demodulator_0, '0']
- [lte_sss_sync_0, cell_id, lte_channel_estimator_0, cell_id]
- [lte_sss_sync_0, cell_id, lte_pbch_decoder_0, cell_id]
- [lte_sss_sync_0, cell_id, lte_pcfich_decoder_0, cell_id]
- [pre_blocks_file_source_0, '0', blocks_deinterleave_0, '0']
- [pre_blocks_file_source_0, '0', blocks_head_0_0, '0']
- [pre_blocks_file_source_0, '0', sync_lte_rough_symbol_sync_cc_0, '0']
- [pre_rational_resampler_xxx_0, '0', sync_lte_rough_symbol_sync_cc_0, '0']
- [sync_lte_rough_symbol_sync_cc_0, '0', lte_pss_sync_0, '0']

metadata:
  file_format: 1
