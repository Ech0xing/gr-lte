options:
  parameters:
    author: Kristian Maier, Johannes Demel
    category: lte
    generate_options: hb
    id: lte_channel_estimator_mimo_4tx
    output_language: python
    title: Channel Estimator MIMO 4TX
  states: {}

blocks:
- name: mymap0
  id: variable
  parameters:
    value: lte.frame_pilot_value_and_position(N_rb_dl, initial_id, 1, 0)
  states: {}
- name: mymap1
  id: variable
  parameters:
    value: lte.frame_pilot_value_and_position(N_rb_dl, initial_id, 1, 1)
  states: {}
- name: mymap2
  id: variable
  parameters:
    value: lte.frame_pilot_value_and_position(N_rb_dl, initial_id, 1, 2)
  states: {}
- name: mymap3
  id: variable
  parameters:
    value: lte.frame_pilot_value_and_position(N_rb_dl, initial_id, 1, 3)
  states: {}
- name: poss0
  id: variable
  parameters:
    value: mymap0[0]
  states: {}
- name: poss1
  id: variable
  parameters:
    value: mymap1[0]
  states: {}
- name: poss2
  id: variable
  parameters:
    value: mymap2[0]
  states: {}
- name: poss3
  id: variable
  parameters:
    value: mymap3[0]
  states: {}
- name: vals0
  id: variable
  parameters:
    value: mymap0[1]
  states: {}
- name: vals1
  id: variable
  parameters:
    value: mymap1[1]
  states: {}
- name: vals2
  id: variable
  parameters:
    value: mymap2[1]
  states: {}
- name: vals3
  id: variable
  parameters:
    value: mymap3[1]
  states: {}
- name: N_rb_dl
  id: parameter
  parameters:
    label: resource blocks
    type: intx
    value: '50'
  states: {}
- name: ain0
  id: pad_source
  parameters:
    label: in
    type: complex
    vlen: 12*N_rb_dl*rxant
  states: {}
- name: cell_id
  id: pad_source
  parameters:
    label: cell_id
    optional: 'True'
    type: message
  states: {}
- name: estimator_key
  id: parameter
  parameters:
    label: Tag Key
    type: str
    value: '"slot"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gnuradio.lte as lte
  states: {}
- name: initial_id
  id: parameter
  parameters:
    label: initial Cell ID
    type: intx
    value: '333'
  states: {}
- name: lte_channel_estimator_vcvc_0
  id: lte_channel_estimator_vcvc
  parameters:
    pilot_carriers: poss0
    pilot_symbols: vals0
    rxant: '2'
    subcarriers: 12 * N_rb_dl
    tag_key: estimator_key
  states: {}
- name: lte_channel_estimator_vcvc_0_0
  id: lte_channel_estimator_vcvc
  parameters:
    pilot_carriers: poss1
    pilot_symbols: vals1
    rxant: '2'
    subcarriers: 12 * N_rb_dl
    tag_key: estimator_key
  states: {}
- name: lte_channel_estimator_vcvc_0_1
  id: lte_channel_estimator_vcvc
  parameters:
    pilot_carriers: poss2
    pilot_symbols: vals2
    rxant: '2'
    subcarriers: 12 * N_rb_dl
    tag_key: estimator_key
  states: {}
- name: lte_channel_estimator_vcvc_0_2
  id: lte_channel_estimator_vcvc
  parameters:
    pilot_carriers: poss3
    pilot_symbols: vals3
    rxant: '2'
    subcarriers: 12 * N_rb_dl
    tag_key: estimator_key
  states: {}
- name: ofdm_estimator_lte_rs_map_generator_m_0
  id: lte_rs_map_generator_m
  parameters:
    N_rb_dl: N_rb_dl
    ant_port: '0'
  states: {}
- name: ofdm_estimator_lte_rs_map_generator_m_0_0
  id: lte_rs_map_generator_m
  parameters:
    N_rb_dl: N_rb_dl
    ant_port: '2'
  states: {}
- name: ofdm_estimator_lte_rs_map_generator_m_1
  id: lte_rs_map_generator_m
  parameters:
    N_rb_dl: N_rb_dl
    ant_port: '1'
  states: {}
- name: ofdm_estimator_lte_rs_map_generator_m_1_0
  id: lte_rs_map_generator_m
  parameters:
    N_rb_dl: N_rb_dl
    ant_port: '3'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: ant_p0_est
    type: complex
    vlen: 12*N_rb_dl*rxant
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: ant_p1_est
    type: complex
    vlen: 12*N_rb_dl*rxant
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: ant_p2_est
    type: complex
    vlen: 12*N_rb_dl*rxant
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: ant_p3_est
    type: complex
    vlen: 12*N_rb_dl*rxant
  states: {}
- name: rxant
  id: parameter
  parameters:
    label: RX antennas
    type: intx
    value: '2'
  states: {}

connections:
- [ain0, '0', lte_channel_estimator_vcvc_0, '0']
- [ain0, '0', lte_channel_estimator_vcvc_0_0, '0']
- [ain0, '0', lte_channel_estimator_vcvc_0_1, '0']
- [ain0, '0', lte_channel_estimator_vcvc_0_2, '0']
- [cell_id, out, ofdm_estimator_lte_rs_map_generator_m_0, cell_id]
- [cell_id, out, ofdm_estimator_lte_rs_map_generator_m_0_0, cell_id]
- [cell_id, out, ofdm_estimator_lte_rs_map_generator_m_1, cell_id]
- [cell_id, out, ofdm_estimator_lte_rs_map_generator_m_1_0, cell_id]
- [lte_channel_estimator_vcvc_0, '0', pad_sink_0, '0']
- [lte_channel_estimator_vcvc_0_0, '0', pad_sink_1, '0']
- [lte_channel_estimator_vcvc_0_1, '0', pad_sink_2, '0']
- [lte_channel_estimator_vcvc_0_2, '0', pad_sink_3, '0']
- [ofdm_estimator_lte_rs_map_generator_m_0, pilots, lte_channel_estimator_vcvc_0, pilots]
- [ofdm_estimator_lte_rs_map_generator_m_0_0, pilots, lte_channel_estimator_vcvc_0_1, pilots]
- [ofdm_estimator_lte_rs_map_generator_m_1, pilots, lte_channel_estimator_vcvc_0_0, pilots]
- [ofdm_estimator_lte_rs_map_generator_m_1_0, pilots, lte_channel_estimator_vcvc_0_2, pilots]

metadata:
  file_format: 1
