options:
  parameters:
    author: Kristian Maier
    category: lte
    generate_options: hb
    id: lte_pss_sync_direct_mimo_2tx
    output_language: python
    title: PSS Sync direct MIMO 2TX
  states: {}

blocks:
- name: taps
  id: variable
  parameters:
    value: filter.optfir.low_pass(1, fftlen*15e3, 472.5e3, 900e3, 0.2, 40)
  states: {}
- name: fftlen
  id: parameter
  parameters:
    label: FFT length
    type: intx
    value: '2048'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: int(fftlen/64)
    taps: taps
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: int(fftlen/64)
    taps: taps
    type: ccc
  states: {}
- name: lte_mimo_pss_coarse_control_0
  id: lte_mimo_pss_coarse_control
  parameters:
    rxant: rxant
  states: {}
- name: lte_mimo_pss_coarse_sync_0
  id: lte_mimo_pss_coarse_sync
  parameters:
    rxant: rxant
    syncl: synclen
  states: {}
- name: lte_mimo_pss_fine_sync_1
  id: lte_mimo_pss_fine_sync
  parameters:
    fftl: fftlen
    grpdelay: int(len(taps)/2)
    rxant: rxant
  states: {}
- name: lte_mimo_pss_tagger_0
  id: lte_mimo_pss_tagger
  parameters:
    fftl: fftlen
    rxant: rxant
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    num_streams: rxant
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: N_id_2
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    num_streams: rxant
    type: complex
  states: {}
- name: rxant
  id: parameter
  parameters:
    label: RX antennas
    type: intx
    value: '2'
  states: {}
- name: synclen
  id: parameter
  parameters:
    type: intx
    value: '4'
  states: {}

connections:
- [fir_filter_xxx_0, '0', lte_mimo_pss_coarse_sync_0, '0']
- [fir_filter_xxx_0_0, '0', lte_mimo_pss_coarse_sync_0, '1']
- [lte_mimo_pss_coarse_control_0, '0', fir_filter_xxx_0, '0']
- [lte_mimo_pss_coarse_control_0, '1', fir_filter_xxx_0_0, '0']
- [lte_mimo_pss_coarse_sync_0, N_id_2, lte_mimo_pss_fine_sync_1, N_id_2]
- [lte_mimo_pss_coarse_sync_0, N_id_2, lte_mimo_pss_tagger_0, N_id_2]
- [lte_mimo_pss_coarse_sync_0, N_id_2, pad_sink_1, in]
- [lte_mimo_pss_coarse_sync_0, coarse_pos, lte_mimo_pss_fine_sync_1, coarse_pos]
- [lte_mimo_pss_coarse_sync_0, control, lte_mimo_pss_coarse_control_0, control]
- [lte_mimo_pss_fine_sync_1, half_frame, lte_mimo_pss_tagger_0, half_frame]
- [lte_mimo_pss_fine_sync_1, lock, lte_mimo_pss_tagger_0, lock]
- [lte_mimo_pss_tagger_0, '0', pad_sink_0, '0']
- [lte_mimo_pss_tagger_0, '1', pad_sink_0, '1']
- [pad_source_0, '0', lte_mimo_pss_coarse_control_0, '0']
- [pad_source_0, '0', lte_mimo_pss_fine_sync_1, '0']
- [pad_source_0, '0', lte_mimo_pss_tagger_0, '0']
- [pad_source_0, '1', lte_mimo_pss_coarse_control_0, '1']
- [pad_source_0, '1', lte_mimo_pss_fine_sync_1, '1']
- [pad_source_0, '1', lte_mimo_pss_tagger_0, '1']

metadata:
  file_format: 1
