options:
  parameters:
    author: Johannes Demel, Kristian Maier
    category: lte
    generate_options: hb
    id: lte_ofdm_demodulator_mimo_2tx
    output_language: python
    title: OFDM Demodulator MIMO 2TX
  states: {}

blocks:
- name: N_rb_dl
  id: parameter
  parameters:
    label: resource blocks
    type: intx
    value: '50'
  states: {}
- name: fftlen
  id: parameter
  parameters:
    label: FFT length
    type: intx
    value: '1024'
  states: {}
- name: lte_extract_subcarriers_vcvc_0
  id: lte_extract_subcarriers_vcvc
  parameters:
    N_rb_dl: N_rb_dl
    fftl: fftlen
  states: {}
- name: lte_extract_subcarriers_vcvc_0_0
  id: lte_extract_subcarriers_vcvc
  parameters:
    N_rb_dl: N_rb_dl
    fftl: fftlen
  states: {}
- name: lte_mimo_remove_cp_0
  id: lte_mimo_remove_cp
  parameters:
    fftl: fftlen
    key: ofdm_key
    rxant: rxant
  states: {}
- name: ofdm_fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftlen
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(fftlen)
  states: {}
- name: ofdm_fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fftlen
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(fftlen)
  states: {}
- name: ofdm_key
  id: parameter
  parameters:
    label: Tag Key
    type: str
    value: '"slot"'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    num_streams: '2'
    type: complex
    vlen: 12*N_rb_dl
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    num_streams: rxant
    type: complex
  states: {}
- name: rxant
  id: parameter
  parameters:
    label: RX antennas
    type: intx
    value: '2'
  states: {}

connections:
- [lte_extract_subcarriers_vcvc_0, '0', pad_sink_0, '0']
- [lte_extract_subcarriers_vcvc_0_0, '0', pad_sink_0, '1']
- [lte_mimo_remove_cp_0, '0', ofdm_fft_vxx_0, '0']
- [lte_mimo_remove_cp_0, '1', ofdm_fft_vxx_0_0, '0']
- [ofdm_fft_vxx_0, '0', lte_extract_subcarriers_vcvc_0, '0']
- [ofdm_fft_vxx_0_0, '0', lte_extract_subcarriers_vcvc_0_0, '0']
- [pad_source_0, '0', lte_mimo_remove_cp_0, '0']
- [pad_source_0, '1', lte_mimo_remove_cp_0, '1']

metadata:
  file_format: 1
