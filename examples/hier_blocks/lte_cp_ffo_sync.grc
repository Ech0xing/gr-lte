options:
  parameters:
    author: Johannes Demel
    category: lte
    description: Cyclic Prefix based synchronization for the fractional frequency offset
    generate_options: hb
    id: lte_cp_ffo_sync
    output_language: python
    title: CP-based FFO Sync
  states: {}

blocks:
- name: cp0
  id: variable
  parameters:
    value: 160 * (fftlen/2048)
  states: {}
- name: cp1
  id: variable
  parameters:
    value: 144 * (fftlen/2048)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: slotl/0.0005
  states: {}
- name: slotl
  id: variable
  parameters:
    value: 7 * fftlen + 6 * cp1 + cp0
  states: {}
- name: fftlen
  id: parameter
  parameters:
    label: FFT length
    type: intx
    value: '2048'
  states: {}
- name: lte_sync_frequency_0
  id: lte_sync_frequency
  parameters:
    fftl: fftlen
    sig: ''
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: sync_ffofrac_lte_sync_frequency_c_0
  id: lte_sync_frequency_c
  parameters:
    fftl: fftlen
    sig: sync_ffofrac_sig
  states: {state: disabled}
- name: sync_ffofrac_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: sync_ffofrac_sig
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}

connections:
- [pad_source_0, '0', sync_ffofrac_multiply_xx_0, '0']
- [sync_ffofrac_multiply_xx_0, '0', lte_sync_frequency_0, '0']
- [sync_ffofrac_multiply_xx_0, '0', pad_sink_0, '0']
- [sync_ffofrac_multiply_xx_0, '0', sync_ffofrac_lte_sync_frequency_c_0, '0']
- [sync_ffofrac_sig, '0', sync_ffofrac_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-395-g4f3dd2f4
